# Keil uVision project smarthome_22.uvprojx, settings and files
target project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smarthome_22
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\Hardware\inc;.\CMSIS;.\STM32F10x_FWLib\inc;.\EDP;.\Network;.\OneNET;.\System\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ./CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group User
    ./User/: main.c
  group System
    ./System/src/: delay.c sys.c usart.c
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c
  group Hardware
    ./Hardware/src/: dht11.c Relay.c
  group Network
    ./Network/: esp8266.c
  group EDP
    ./EDP/: EdpKit.c
  group OneNET
    ./OneNET/: onenet.c
